DESCRIPTION = "SpaceLinux development image"

require spacelinux-image-common.inc
