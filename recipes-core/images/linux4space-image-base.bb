DESCRIPTION = "Linux4Space base image"

require linux4space-image-common.inc
